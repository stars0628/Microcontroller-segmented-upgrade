#include "Segmented_IAP.h"
#include "string.h"

//有关串口和IAP的头文件
#include "CommUART1.h"
#include "IAP.h"


//分段IAP相关值初始化
App_Upgrade_Package_Data bin_message = { // bin文件信息
    .bin_write_flash_addr = FLASH_APP1_ADDR,
    .other_message_length = OTHER_LENGTH
};

Serial_Port_Data_Information serial_message = {0}; // 串口接收信息

Iap_Flag iap_flag = {0};//标志信息

//////-------------Modbus CRC16校验------------------------------////
// 下位机建议使用查表法，查表法是以空间换时间，速度较快
// 将查表的数组类型定义为const，存放在Flash中，运行时不占用RAM。
const static unsigned char auchCRCHi[] = {
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0,
    0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,
    0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1,
    0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1,
    0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0,
    0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40,
    0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1,
    0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0,
    0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40,
    0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,
    0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0,
    0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,
    0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
    0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,
    0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40,
    0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1,
    0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0,
    0x80, 0x41, 0x00, 0xC1, 0x81, 0x40
};
static const char auchCRCLo[] = {
    0x00, 0xC0, 0xC1, 0x01, 0xC3, 0x03, 0x02, 0xC2, 0xC6, 0x06,
    0x07, 0xC7, 0x05, 0xC5, 0xC4, 0x04, 0xCC, 0x0C, 0x0D, 0xCD,
    0x0F, 0xCF, 0xCE, 0x0E, 0x0A, 0xCA, 0xCB, 0x0B, 0xC9, 0x09,
    0x08, 0xC8, 0xD8, 0x18, 0x19, 0xD9, 0x1B, 0xDB, 0xDA, 0x1A,
    0x1E, 0xDE, 0xDF, 0x1F, 0xDD, 0x1D, 0x1C, 0xDC, 0x14, 0xD4,
    0xD5, 0x15, 0xD7, 0x17, 0x16, 0xD6, 0xD2, 0x12, 0x13, 0xD3,
    0x11, 0xD1, 0xD0, 0x10, 0xF0, 0x30, 0x31, 0xF1, 0x33, 0xF3,
    0xF2, 0x32, 0x36, 0xF6, 0xF7, 0x37, 0xF5, 0x35, 0x34, 0xF4,
    0x3C, 0xFC, 0xFD, 0x3D, 0xFF, 0x3F, 0x3E, 0xFE, 0xFA, 0x3A,
    0x3B, 0xFB, 0x39, 0xF9, 0xF8, 0x38, 0x28, 0xE8, 0xE9, 0x29,
    0xEB, 0x2B, 0x2A, 0xEA, 0xEE, 0x2E, 0x2F, 0xEF, 0x2D, 0xED,
    0xEC, 0x2C, 0xE4, 0x24, 0x25, 0xE5, 0x27, 0xE7, 0xE6, 0x26,
    0x22, 0xE2, 0xE3, 0x23, 0xE1, 0x21, 0x20, 0xE0, 0xA0, 0x60,
    0x61, 0xA1, 0x63, 0xA3, 0xA2, 0x62, 0x66, 0xA6, 0xA7, 0x67,
    0xA5, 0x65, 0x64, 0xA4, 0x6C, 0xAC, 0xAD, 0x6D, 0xAF, 0x6F,
    0x6E, 0xAE, 0xAA, 0x6A, 0x6B, 0xAB, 0x69, 0xA9, 0xA8, 0x68,
    0x78, 0xB8, 0xB9, 0x79, 0xBB, 0x7B, 0x7A, 0xBA, 0xBE, 0x7E,
    0x7F, 0xBF, 0x7D, 0xBD, 0xBC, 0x7C, 0xB4, 0x74, 0x75, 0xB5,
    0x77, 0xB7, 0xB6, 0x76, 0x72, 0xB2, 0xB3, 0x73, 0xB1, 0x71,
    0x70, 0xB0, 0x50, 0x90, 0x91, 0x51, 0x93, 0x53, 0x52, 0x92,
    0x96, 0x56, 0x57, 0x97, 0x55, 0x95, 0x94, 0x54, 0x9C, 0x5C,
    0x5D, 0x9D, 0x5F, 0x9F, 0x9E, 0x5E, 0x5A, 0x9A, 0x9B, 0x5B,
    0x99, 0x59, 0x58, 0x98, 0x88, 0x48, 0x49, 0x89, 0x4B, 0x8B,
    0x8A, 0x4A, 0x4E, 0x8E, 0x8F, 0x4F, 0x8D, 0x4D, 0x4C, 0x8C,
    0x44, 0x84, 0x85, 0x45, 0x87, 0x47, 0x46, 0x86, 0x82, 0x42,
    0x43, 0x83, 0x41, 0x81, 0x80, 0x40
};

// crc16校验
uint16_t CRC16(uint8_t *puchMsg, uint16_t usDataLen)
{
    unsigned char uchCRCHi = 0xFF; /* high byte of CRC initialized */
    unsigned char uchCRCLo = 0xFF; /* low byte of CRC initialized */
    unsigned uIndex;               /* will index into CRC lookup table */
    while (usDataLen--)            /* pass through message buffer */
    {
        uIndex = uchCRCLo ^ *puchMsg++; /* calculate the CRC */
        uchCRCLo = uchCRCHi ^ auchCRCHi[uIndex];
        uchCRCHi = auchCRCLo[uIndex];
    }
    // 根据需要对校验值处理（高低位不同）
    return (uchCRCLo << 8 | uchCRCHi); // 低位在左高位在右
    // return (uchCRCHi << 8 | uchCRCLo) ;//高位在左低位在右
}

// 命令或bin文件判断并处理的简单实现
// #error 可以将此函数放在串口接收中断中或保证串口接受完完整数据后运行，建议使用DMA串口
void cmd_or_data_deal(uint8_t *serial_data, uint32_t length)
{
    uint16_t crc_get = serial_data[length - 2] << 8 | serial_data[length - 1]; // 串口获得的crc
    uint16_t crc_16 = CRC16(serial_data, length - 2);                          // 计算出的crc
    if (crc_16 == crc_get) {
        if (serial_data[0] == 0x0a && serial_data[1] == 0x0b && serial_data[length - 4] == 0xb0 && serial_data[length - 3] == 0xa0) { // 帧头为0a 0b帧尾为a0 b0则定义为命令模式，第二个数据为功能码

            //将有关IAP寄存器重新初始化并赋值
            memset(&bin_message,0,sizeof(App_Upgrade_Package_Data));
            memset(&serial_message,0,sizeof(Serial_Port_Data_Information));
            memset(&iap_flag,0,sizeof(Iap_Flag));
            bin_message.bin_write_flash_addr = FLASH_APP1_ADDR,
            bin_message.other_message_length = OTHER_LENGTH;

            switch (serial_data[2]) {
            case 0x11: // 功能码11
                bin_message.bin_num = (serial_data[3] << 8) | serial_data[4];//获取bin数量
                iap_flag.star_flag = 1;

                U1_TxBuffer[0] = 0x0a;
                U1_TxBuffer[1] = 0x0b;
                U1_TxBuffer[2] = 0x01;
                U1_TxBuffer[3] = 0xb0;
                U1_TxBuffer[4] = 0xa0;
                DMA_send(5);

                break;
            case 0x00: // 功能码00
                iap_flag.star_flag = 0;
                bin_message.bin_write_flash_addr = FLASH_APP1_ADDR;
                U1_TxBuffer[0] = 0x0a;
                U1_TxBuffer[1] = 0x0b;
                U1_TxBuffer[2] = 0x00;
                U1_TxBuffer[3] = 0xb0;
                U1_TxBuffer[4] = 0xa0;
                DMA_send(5);

                break;
            }
        } else { // 否则认为传输的是bin
            Transmission_and_Upgrade(serial_data, length);
        }
    } else {
    }
}

// 此函数可单独使用，应放在串口接收中断中或保证串口接受完完整数据后运行
void Transmission_and_Upgrade(uint8_t *serial_data, uint32_t length) // 传入串口收到的数据和长度
{
    uint16_t data_crc = 0;        // 收到的数据计算校验值
    uint32_t bin_data_length = 0; // 一段数据中真实有效的bin文件长度

    if (length && iap_flag.star_flag == 1) {
        serial_message.bin_get_length = length;
        length = 0;
        bin_message.bin_crc = serial_data[serial_message.bin_get_length - 2] << 8 | serial_data[serial_message.bin_get_length - 1];
        data_crc = CRC16(serial_data, serial_message.bin_get_length - 2);
        if (bin_message.bin_crc != data_crc) { // 计算出的校验值与获得的校验值不同，重新请求数据

            // #error通过串口向软件发送信号请求重发本段数据
            U1_TxBuffer[0] = 0x0a;
            U1_TxBuffer[1] = 0x0b;
            serial_data[2] = 0x00;
            U1_TxBuffer[3] = 0xb0;
            U1_TxBuffer[4] = 0xa0;
            DMA_send(5);

        } else {
            iap_flag.receive_bin_segment_done = 1;
            bin_message.bin_count++;
        }
    }

    /* 接收数据完毕，写入Flash */
    if (iap_flag.receive_bin_segment_done) {
        iap_flag.receive_bin_segment_done = 0;
        bin_data_length = serial_message.bin_get_length - bin_message.other_message_length;
        serial_message.bin_get_totle_length += bin_data_length;

        // #error在此处添加对flash操作的函数(传入参数)
        MID_FLASH_E2P_Write(bin_message.bin_write_flash_addr, serial_data, bin_data_length); // 将接收到的升级文件写入到Flash的函数

        bin_message.bin_write_flash_addr = bin_message.bin_write_flash_addr + bin_data_length;

        // 检测是否接受完所有数据，未接收完成则请求下一段数据
        if (bin_message.bin_count != bin_message.bin_num) {

            // #error 此处串口向软件发送请求下一段数据信号
            U1_TxBuffer[0] = 0x0a;
            U1_TxBuffer[1] = 0x0b;
            U1_TxBuffer[2] = 0x01;
            U1_TxBuffer[3] = 0xb0;
            U1_TxBuffer[4] = 0xa0;
            DMA_send(5);

        } else {
            // 所有数据都已接收并写入到flash，将execute_app_done置1
            iap_flag.execute_app_done = 1;
            iap_flag.star_flag = 0;

            // #error 此处串口向软件发送升级成功信号
            U1_TxBuffer[0] = 0x0a;
            U1_TxBuffer[1] = 0x0b;
            U1_TxBuffer[2] = 0x10;
            U1_TxBuffer[3] = 0xb0;
            U1_TxBuffer[4] = 0xa0;
            DMA_send(5);
        }
    }
}
